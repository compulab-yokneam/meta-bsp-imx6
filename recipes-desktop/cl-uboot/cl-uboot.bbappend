PACKAGE_ARCH = "${MACHINE_ARCH}"
COMPATIBLE_MACHINE = "(cl-som-imx6|cl-som-imx6ul|cm-fx6-evk)"
