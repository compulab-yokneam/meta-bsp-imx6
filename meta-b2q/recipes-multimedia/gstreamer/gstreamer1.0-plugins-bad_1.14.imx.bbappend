#Remove vulkan as it's incompatible for i.MX 8M Mini
PACKAGECONFIG_remove_mx6 = " vulkan"
