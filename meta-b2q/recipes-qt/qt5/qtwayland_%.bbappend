SRC_URI_remove = " \
	file://0001-Fix-crash-when-wl_surface-was-destroyed-before-eglDe.patch \
        file://0001-tst_client.cpp-Fix-no-opengl-build.patch \
"
