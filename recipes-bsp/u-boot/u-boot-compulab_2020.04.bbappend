FILESEXTRAPATHS_prepend := "${THISDIR}/compulab/imx6:"

require compulab/imx6.inc

COMPATIBLE_MACHINE = "cl-som-imx6"
